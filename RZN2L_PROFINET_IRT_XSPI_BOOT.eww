<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\RZN2L_PROFINET_IRT_XSPI_BOOT.ewp</path>
    </project>
    <batchBuild/>
</workspace>
